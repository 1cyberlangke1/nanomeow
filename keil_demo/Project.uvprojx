# Keil uVision project Project.uvprojx, settings and files
target nanomeow (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 v6Lto=1 wLevel=2
  c define: NM_VECTORS_IN_STARTUP
  c misc: -Oz -ffreestanding -fno-common -fno-unwind-tables -fno-asynchronous-unwind-tables -ffunction-sections -fdata-sections -std=c99 -DNM_BOARD_CONFIG=\"config.h\" -DNM_GEN_NO_REP_PENALTY
  c include: .\User;..\infer\c\engine;..\infer\c\generated;..\infer\c\display;..\infer\c\platform;..\infer\c;..\infer
  asm misc: --pd "__MICROLIB SETA 1"
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --lto
  group Start
    ./Start/: startup_nanomeow.s
  group User
    ./User/: main.c config.h
  group Engine
    ../infer/c/engine/: nanomeow.c nm_gen.c nanomeow.h nm_fixed.h nm_gen.h nm_utf8.h
    ../infer/c/generated/: nm_weights.c nm_font.c nm_font.h nm_lut.h
    ../infer/c/display/: nm_oled.c nm_oled_port.c nm_oled.h
    ../infer/c/platform/: nm_board.h nm_stm32f103.h
    ../infer/: model_cfg.h
